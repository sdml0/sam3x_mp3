# Keil uVision project mp3_3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAM3X8E Atmel
  pack: Atmel.SAM3X_DFP.1.0.50
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20080000,0x00008000) IROM(0x00080000,0x00040000) IROM2(0x000C0000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mp3_3 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x80000 size 0x40000
  memory RVCT5: ROM 0xc0000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  group Source Group 1
    ./: MP3 v2.c
    ./Helix/: bitstream.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs_fixpt.c asmpoly.s asmmisc.s
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
